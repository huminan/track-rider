# Keil uVision project rider.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC-STC12
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: rider +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c STC12C5A60S2.H gprs.c gps.c uart.c gprs.h gps.h sys.h uart.h timer.h timer.c
